# Repository asukiaaa/IRIS-OHYAMA-IHK-T35-I2C-Controller-PCB

File README.md:

# IRIS-OHYAMA-IHK-T35-I2C-Controller-PCB

A pcb to make IH cooking heater as a I2C device.

# Components

- [n-ch MOSFET SOT-23 GSD](http://akizukidenshi.com/catalog/g/gI-04232/)
- [Diode SOD-123F](http://akizukidenshi.com/catalog/g/gI-06014/)
- atmega328p or atmega328pb
- 0.1uf condensors
- leds
- 1k and 2k resistors
- XH Connector 1x5 and 1x2

# Reference

- [Arduino Nano Rev3.2](https://www.arduino.cc/en/uploads/Main/Arduino_Nano-Rev3.2-SCH.pdf)
- [電磁調理器の信号線を引き出してArduinoで制御してみた](https://asukiaaa.blogspot.com/2020/03/irisohyama-IHK-T35-arduino.html)
- [1口IHコンロ（1400W） ](https://www.irisohyama.co.jp/products/electrical-appliances/cooking-appliances/ih-cooking-heater/1-ih-cooking-heater/1-ih-cooking-heater-tabletop-1400)
- [IHコンロIHK-T35 取扱説明書(PDF)](https://www.irisohyama.co.jp/products/manual/pdf/572260.pdf)

## KiCad design main_pcb/IRIS-OHYAMA-IHK-T35-I2C-Controller.kicad_pcb

Parts:
C1, C2: 0.1uf; C_0402_1005Metric
CN1: Conn_01x05; JST_XH_S5B-XH-A_1x05_P2.50mm_Horizontal
D1: Level1; LED_0603_1608Metric
D2: Level2; LED_0603_1608Metric
D3: Level3; LED_0603_1608Metric
D4: Level4; LED_0603_1608Metric
D5: Level5; LED_0603_1608Metric
D6: Level6; LED_0603_1608Metric
D7: NomalState; LED_0603_1608Metric
D8: OilState; LED_0603_1608Metric
D9, D10, D11, D12, D13, D14: D; D_SOD-123F
J1: Grove; NS-Tech_Grove_1x04_P2mm_Horizontal
J2: Conn_01x06; 2x03_P2.54mm_Pads
J3: thermistor; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
JP1: ADDR0_NO; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: ADDR1_NO; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
KEY1: normal_power; SW_PUSH_6mm_center_like_smd
KEY2: power_up; SW_PUSH_6mm_center_like_smd
KEY3: power_down; SW_PUSH_6mm_center_like_smd
KEY5: oil_power; SW_PUSH_6mm_center_like_smd
Q1, Q2, Q3, Q4: Q_NMOS_DGS; SOT-23
R1, R2, R3, R4, R5, R6, R7, R8, R12, R14, R15, R16, R17, R18, R19, R20: 1k; R_0603_1608Metric
R9, R10, R11, R13: 2k; R_0603_1608Metric
U1: 74HC164; SOP-14_4.4x9.2mm_P1.27mm
U2: ATmega328P-MU; QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm

Connections:
+5V: CN1.5, D13.2 (A), U1.14 (VCC)
/A0: D9.1 (K), R1.2, R9.2, U1.3 (Q0), U2.23 (PC0)
/A1: D11.1 (K), R2.2, R10.2, U1.4 (Q1), U2.24 (PC1)
/A2: D12.1 (K), R3.2, R11.2, U1.5 (Q2), U2.25 (PC2)
/A3: R4.2, U1.6 (Q3), U2.26 (PC3)
/A6: J3.1, U2.19 (PE2)
/ADDR0: JP1.1, U2.30 (PD0)
/ADDR1: JP2.1, U2.31 (PD1)
/CLK: CN1.3, U1.8 (CP), U2.1 (PD3)
/Controller_5V: C2.1, D13.1 (K), D14.1 (K), U2.4 (VCC), U2.18 (AVCC)
/D2: CN1.1, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), U2.32 (PD2)
/D4: CN1.2, KEY1.1, KEY2.1, KEY3.1, KEY5.1, R15.1, R16.1, R19.1, R20.1, U1.1 (DSA), U1.2 (DSB), U2.2 (PD4)
/D5: Q4.2 (G), R18.1, U2.9 (PD5)
/D6: Q2.2 (G), R14.1, U2.10 (PD6)
/D7: Q3.2 (G), R17.1, U2.11 (PD7)
/D8: Q1.2 (G), R12.1, U2.12 (PB0)
/D10: D10.1 (K), R5.2, R13.2, U1.10 (Q4), U2.14 (PB2)
/D11: J2.4, R6.2, U1.11 (Q5), U2.15 (PB3)
/D12: J2.1, R7.2, U1.12 (Q6), U2.16 (PB4)
/D13: J2.3, R8.2, U1.13 (Q7), U2.17 (PB5)
/GROVE_5V: D14.2 (A), J1.3, J2.2
/RST: J2.5, U2.29 (~RESET~/PC6)
/SCL: J1.1, U2.28 (PC5)
/SDA: J1.2, U2.27 (PC4)
GND: C1.2, C2.2, CN1.4, J1.4, J2.6, JP1.2, JP2.2, R12.2, R14.2, R17.2, R18.2, U1.7 (GND), U2.5 (GND), U2.21 (GND), U2.33 (GND)
unnamed: C1.1, U2.20 (AREF)
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), R3.1
unnamed: D4.2 (A), R4.1
unnamed: D5.2 (A), R5.1
unnamed: D6.2 (A), R6.1
unnamed: D7.2 (A), R7.1
unnamed: D8.2 (A), R8.1
unnamed: D9.2 (A), Q1.3 (S)
unnamed: D10.2 (A), Q2.3 (S)
unnamed: D11.2 (A), Q3.3 (S)
unnamed: D12.2 (A), Q4.3 (S)
unnamed: KEY1.2, R9.1
unnamed: KEY2.2, R10.1
unnamed: KEY3.2, R11.1
unnamed: KEY5.2, R13.1
unnamed: Q1.1 (D), R15.2
unnamed: Q2.1 (D), R16.2
unnamed: Q3.1 (D), R19.2
unnamed: Q4.1 (D), R20.2

Board: 2 copper layers, 199.5 x 35.0 mm, 58 parts (3 on the bottom side), 46 nets.

Other parts of the board:
REF1, REF2, REF3, REF4, REF5, REF6: MountingHole_4.3mm_M4_Pad

## KiCad design i2c_connector_on_panel/i2c_connector_on_panel.kicad_pcb

Parts:
J1, J2: Conn_01x04; NS-Tech_Grove_1x04_P2mm_Horizontal
J3: Conn_01x04; NS-Tech_Grove_1x04_P2mm_Vertical

Connections:
/SCL: J1.1, J2.1, J3.1
/SDA: J1.2, J2.2, J3.2
GND: J1.4, J2.4, J3.4
VCC: J1.3, J2.3, J3.3

Board: 2 copper layers, 19.0 x 27.0 mm, 3 parts (1 on the bottom side), 4 nets.

## Commit log

2020-04-07 Add license info
2020-05-24 Put footprints in 203.5x35mm
2020-05-24 Change outline to 199.5x35mm
2020-05-24 Update silk info
2020-06-21 Change mosfet to GSD
